/**********************************************************************
 *
 * Filename:    sis_benchmark.c
 *
 * Description: Fast use sisapi_sdk
 *
 * Notes:       The parameters for each supported sisapi standard are
 *				defined in the header file aes.h.  The implementations
 *				here should stand up to further additions to that list.
 *
 *
 * Copyright (c) 2019 by ICWORKSHOP.  This software is placed into
 * the public domain and may be used for any purpose.  However, this
 * notice must not be changed or removed and no warranty is either
 * expressed or implied by its publication or distribution.
 **********************************************************************/

/**
 * @file    sis_benchmark.c
 * @brief   Implementation of sis_benchmark.h
 */
#include "sissdk_api.h"


#ifdef ENABLE_SIS_BENCHMARK
//aes128cbc_test
static uint8_t testdat[256] = {
																	0x52, 0x09, 0x6a, 0xd5, 0x30, 0x36, 0xa5, 0x38, 0xbf, 0x40, 0xa3, 0x9e, 0x81, 0xf3, 0xd7, 0xfb,
																	0x7c, 0xe3, 0x39, 0x82, 0x9b, 0x2f, 0xff, 0x87, 0x34, 0x8e, 0x43, 0x44, 0xc4, 0xde, 0xe9, 0xcb,
																	0x54, 0x7b, 0x94, 0x32, 0xa6, 0xc2, 0x23, 0x3d, 0xee, 0x4c, 0x95, 0x0b, 0x42, 0xfa, 0xc3, 0x4e,
																	0x08, 0x2e, 0xa1, 0x66, 0x28, 0xd9, 0x24, 0xb2, 0x76, 0x5b, 0xa2, 0x49, 0x6d, 0x8b, 0xd1, 0x25,
																	0x72, 0xf8, 0xf6, 0x64, 0x86, 0x68, 0x98, 0x16, 0xd4, 0xa4, 0x5c, 0xcc, 0x5d, 0x65, 0xb6, 0x92,
																	0x6c, 0x70, 0x48, 0x50, 0xfd, 0xed, 0xb9, 0xda, 0x5e, 0x15, 0x46, 0x57, 0xa7, 0x8d, 0x9d, 0x84,
																	0x90, 0xd8, 0xab, 0x00, 0x8c, 0xbc, 0xd3, 0x0a, 0xf7, 0xe4, 0x58, 0x05, 0xb8, 0xb3, 0x45, 0x06,
																	0xd0, 0x2c, 0x1e, 0x8f, 0xca, 0x3f, 0x0f, 0x02, 0xc1, 0xaf, 0xbd, 0x03, 0x01, 0x13, 0x8a, 0x6b,
																	0x3a, 0x91, 0x11, 0x41, 0x4f, 0x67, 0xdc, 0xea, 0x97, 0xf2, 0xcf, 0xce, 0xf0, 0xb4, 0xe6, 0x73,
																	0x96, 0xac, 0x74, 0x22, 0xe7, 0xad, 0x35, 0x85, 0xe2, 0xf9, 0x37, 0xe8, 0x1c, 0x75, 0xdf, 0x6e,
																	0x47, 0xf1, 0x1a, 0x71, 0x1d, 0x29, 0xc5, 0x89, 0x6f, 0xb7, 0x62, 0x0e, 0xaa, 0x18, 0xbe, 0x1b,
																	0xfc, 0x56, 0x3e, 0x4b, 0xc6, 0xd2, 0x79, 0x20, 0x9a, 0xdb, 0xc0, 0xfe, 0x78, 0xcd, 0x5a, 0xf4,
																	0x1f, 0xdd, 0xa8, 0x33, 0x88, 0x07, 0xc7, 0x31, 0xb1, 0x12, 0x10, 0x59, 0x27, 0x80, 0xec, 0x5f,
																	0x60, 0x51, 0x7f, 0xa9, 0x19, 0xb5, 0x4a, 0x0d, 0x2d, 0xe5, 0x7a, 0x9f, 0x93, 0xc9, 0x9c, 0xef,
																	0xa0, 0xe0, 0x3b, 0x4d, 0xae, 0x2a, 0xf5, 0xb0, 0xc8, 0xeb, 0xbb, 0x3c, 0x83, 0x53, 0x99, 0x61,
																	0x17, 0x2b, 0x04, 0x7e, 0xba, 0x77, 0xd6, 0x26, 0xe1, 0x69, 0x14, 0x63, 0x55, 0x21, 0x0c, 0x7d };

static uint8_t output_1[256],output_2[256];
																	
//aes128cbc test key
static uint8_t testKey[16] = { 0x96, 0xac, 0x74, 0x22, 0xe7, 0xad, 0x35, 0x85, 0xe2, 0xf9, 0x37, 0xe8, 0x1c, 0x75, 0xdf, 0x6e	};

//aes128cbc test iv
static uint8_t _testIv[16] = { 0x72, 0xf8, 0xf6, 0x64, 0x86, 0x68, 0x98, 0x16, 0xd4, 0xa4, 0x5c, 0xcc, 0x5d, 0x65, 0xb6, 0x92	};
static uint8_t testIv[16] =  { 0x72, 0xf8, 0xf6, 0x64, 0x86, 0x68, 0x98, 0x16, 0xd4, 0xa4, 0x5c, 0xcc, 0x5d, 0x65, 0xb6, 0x92	};

//crc32
uint32_t m_crc32;

extern int sissdk_ecdsa_init(void);


extern uint8_t PUBLICKEY_CART;		//for benchmark public key
extern uint8_t SIGN_CART;					//for benchmark sign
extern uint8_t CPU_ID;						//for benchmark cpuid
extern uint8_t PRIVATE_CART;			//for benchmark private key

static uint8_t * p_public_key  = &PUBLICKEY_CART;
//static uint8_t * p_sign_cart 	 = &SIGN_CART;
static uint8_t * p_cpuid_data	 = &CPU_ID;
static uint8_t * p_private_key = &PRIVATE_CART;

static uint8_t	 a_sign_dy[CERTIFICATION_SIG_MAX];
static size_t		 a_sign_size = 0;

/**
 * \brief  This function is used for testing purposes
 *
 * \return         none.
 */

extern uint32_t uwTick;

void sis_benchmark(void)
{
	uint32_t uwTickStart,uwTickEnd;
	//-------------------------------Aes128 CBC test---------------------------------

	sis_log(LogDebug,"AES-CBC test\r\n");
	//encrypt
	memcpy(_testIv,testIv,sizeof(testIv));	//restore iv
	encrypt_buffer_cbc(testKey,_testIv,testdat,sizeof(testdat), output_1);
	//decrypt
	memcpy(_testIv,testIv,sizeof(testIv));	//restore iv
	decrypt_buffer_cbc(testKey,_testIv,output_1, sizeof(output_1), output_2);
	
	if(memcmp(testdat,output_2,sizeof(testdat)) != 0){
		sis_log(LogError,"AES-CBC Error\r\n");
	}
	
	//Crc32
	sis_log(LogDebug,"Crc32 test\r\n");
	m_crc32 = crc32(testdat,sizeof(testdat));
	sis_log(LogDebug,"Crc32:0x%08x\r\n",m_crc32);
	
	//sign
	uwTickStart = uwTick;
	if(sissdk_ecdsa_sign(p_private_key,p_cpuid_data,96,a_sign_dy,&a_sign_size)){
		sis_log(LogDebug,"Sign ok...\r\n");
	}
	else{
		sis_log(LogDebug,"Sign Error...\r\n");
	}
	uwTickEnd = uwTick;
	sis_log(LogDebug,"---------------Elapsed time : %d ms (Base:64Mhz)---------------\r\n",uwTickEnd - uwTickStart);
	
	//verfiy sign
	uwTickStart = uwTick;
	if(sissdk_ecdsa_verify(p_public_key,p_cpuid_data,96,a_sign_dy,a_sign_size)){
		sis_log(LogDebug,"verify passed...\r\n");
	}
	else{
		sis_log(LogDebug,"verify error...\r\n");
	}
	uwTickEnd = uwTick;
	sis_log(LogDebug,"---------------Elapsed time : %d ms (Base:64Mhz)---------------\r\n",uwTickEnd - uwTickStart);
}

#endif


